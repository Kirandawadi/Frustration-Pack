# Keil uVision project AGRO_DOCTORF4.uvprojx, settings and files
target AGRO_DOCTORF4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AGRO_DOCTORF4
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;                                ../Drivers/STM32F4xx_HAL_Driver/Inc;                                ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                ../Drivers/CMSIS/Include;                                ..\Inc;                                ..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c tim.c gpio.c usart.c i2c.c adc.c
    ../Inc/: STEPPER.h
    ./: STEPPER.c Info.txt PID.c PID.h mpu6050.c mpu6050.h variables.h Headers.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
software components: CMSIS:CORE 4.1.0
